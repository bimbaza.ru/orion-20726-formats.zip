Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:17:15+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcFurnishingElement: Изделие бетонное благоустройства, ZSK-BKP31-54 Площадка контейнерная ПК-2 (3000×1500)
In: Площадка
Description: Изделие бетонное благоустройства. Площадка контейнерная ПК-2 (3000×1500); Material: Бетон (сборная конструкция)
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-BKP31-54; ModelReference: Площадка контейнерная ПК-2 (3000×1500); ProductionYear: 2026; ArticleNumber: ZSK-BKP31-54
ORION_Изделие - Артикул: ZSK-BKP31-54; Артикул прежний: SD-BKP31-54; Наименование: Площадка контейнерная ПК-2 (3000×1500); Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 3000×1500 мм; Материал: Бетон (сборная конструкция); Цена: 168 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/concrete/20726; Код КСИ: CPr>EDC010; Класс КСИ: Навес площадки для мусороконтейнеров; Коды КСР: …
ADSK - ADSK_Наименование: Площадка контейнерная ПК-2 (3000×1500); ADSK_Марка: ZSK-BKP31-54; ADSK_Код изделия: ZSK-BKP31-54; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Бетон (сборная конструкция); ADSK_URL страницы изделия: https://зск.рф/catalog/concrete/20726
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDC010; ZSK_Артикул_прежний: SD-BKP31-54
Qto_ORION - Длина: 3000 mm; Ширина: 1500 mm; Высота: 0 mm
